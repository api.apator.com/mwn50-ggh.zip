Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN50-G IP65.IFC
Time: 2025-08-04T06:27:04
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 0000-002761-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: 2000-630000-1/Ko³ek walcowy PN-85021 1,5 x 16-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie8
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-2-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: plomba-1-solid2
In: Default Storey
PredefinedType: ELEMENT
