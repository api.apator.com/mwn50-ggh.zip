Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MNW50-G IP68.IFC
Time: 2025-08-04T06:33:23
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie8
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Plomba fi10-2-solid1
In: Default Storey
PredefinedType: ELEMENT
