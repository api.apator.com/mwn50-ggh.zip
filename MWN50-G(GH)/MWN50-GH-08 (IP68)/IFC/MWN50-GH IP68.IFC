Properties of the parts of a building model (IFC4)

# File
Description: IFC4
File name: MWN50-GH IP68.IFC
Time: 2025-08-04T06:48:48
Written by: SwIFC
Made in: SolidWorks 2019

# IfcSite, Default Site
RefLatitude: 0, 0, 0, 0; RefLongitude: 0, 0, 0, 0; RefElevation: 0

# IfcBuildingStorey, Default Storey
In: Default Building
Elevation: 0

# IfcBuildingElementProxy: 5003-110009-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Dodanie-wyci¹gniêcie11
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Drut do plomb, miedziany w oplocie 0,5x0,300 mwn_neu-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nasada 75-T-2-solid2
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nasada 75-T-2-solid3
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-1-solid1
In: Default Storey
PredefinedType: ELEMENT

# IfcBuildingElementProxy: Nitoko³ek 2,89x6,35 - A2-2-solid1
In: Default Storey
PredefinedType: ELEMENT
